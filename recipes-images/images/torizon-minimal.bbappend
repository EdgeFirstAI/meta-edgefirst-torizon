IMAGE_INSTALL:append = " packagegroup-edgefirst-torizon"
